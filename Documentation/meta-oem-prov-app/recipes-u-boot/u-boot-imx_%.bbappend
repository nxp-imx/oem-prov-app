FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://spsdk-support.cfg"
